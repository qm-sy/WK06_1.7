# Keil uVision project WK06_1.7.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: WK06_1.7 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\Inc;..\Core\Inc;..\Drivers;..\Emembed\Inc;..\Middlewares;..\SYSTEM
  group START
    ./: STARTUP.A51
  group Core
    ../Core/Src/: adc.c eeprom.c gpio.c main.c pwm.c timer.c uart.c
  group BSP
    ../BSP/Src/: communication.c eeprom_crl.c ntc.c power_crl.c
  group SYSTEM
    ../SYSTEM/: delay.c delay.h stdio.h sys.h
  group Emembed
    ../Emembed/Src/: modbus_rtu.c common.c
